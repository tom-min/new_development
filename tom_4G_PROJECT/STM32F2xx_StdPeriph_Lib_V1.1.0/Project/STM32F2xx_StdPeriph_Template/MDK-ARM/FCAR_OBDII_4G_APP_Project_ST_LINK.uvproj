# Keil uVision project FCAR_OBDII_4G_APP_Project_ST_LINK.uvproj, settings and files
target STM322xG_EVAL (ARM-ADS)
  device: STM32F205VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F2xx_FCAR_OBDII_4G_APP_V1_00_20190327 +hex
  AfterMake: fromelf --bin --output .\STM322xG_EVAL\STM32F2xx_FCAR_OBDII_4G_APP_V1_03_HONDA.bin .\STM322xG_EVAL\STM32F2xx_FCAR_OBDII_4G_APP_V1_00_20190327.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM322xG_EVAL, STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\USER;..\USER\ECU_DRV;..\USER\INCLUDE;..\USER\uart;..\USER\USER;..\USER\hardwaretest;..\USER;..\USER\bluewifi;..\USER\ezxml-0.8.6\ezxml;..\USER\mxml-3.0\vcnet;..\USER\mxml-3.0\xcode;..\USER\mxml-3.0;..\USER\FatFS;..\USER\FreeRTOS\include;..\USER\FreeRTOS\portable\RVDS\ARM_CM3;..\USER\BootLoader;..\USER\cJSON;..\USER\Encryption_Algorithm;..\USER\4G_DRV;..\USER\STD_OBDII
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../: main.c stm32f2xx_it.c
    ../USER/: hardware.c maingvar.c mmain.c usart1.c user_queue.c RTC.c userfatfs.c Iwdg.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_fsmc_sram.c stm322xg_eval_ioe.c stm322xg_eval_lcd.c stm322xg_eval.c
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group CMSIS
    ../: system_stm32f2xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
  group USER
    ../USER/: usart1.c IIC.c
  group ECU_DRV
    ../USER/ECU_DRV/: crc.c crc.h NewSoftUart.c NewSoftUart.h PassThru.c PassThru.h PassThru_BENZ.c PassThru_BENZ.h PassThru_CAN.c PassThru_CAN.h PassThru_ISO.c PassThru_ISO.h PassThru_KWP.c PassThru_KWP.h PassThru_PLUSE.c PassThru_PLUSE.h PassThru_PWM.c PassThru_PWM.h PassThru_VPW.c PassThru_VPW.h PassThru_WAVE.c PassThru_WAVE.h selftest.c selftest.h code.c VCI_queue.c
  group INCLUDE
    ../USER/INCLUDE/: config.h PortAssign.h user_stm32f2xx.h
  group uart
    ../USER/uart/: adc.c adc.h bluewifi.c bluewifi.h can.c CAN.h hardware.h mcu_uart.h pwm_output.c pwm_output.h Time.c Time.h
  group SPI_FLASH
    ../USER/SPI_FLASH/: spi_test.c spi_flash.c spi_flash.h
  group FatFS
    ../USER/FatFS/: diskio.c ff.c
    ../USER/FatFS/option/: syscall.c unicode.c
  group hardwaretest
    ../USER/hardwaretest/: hardwaretest.c
  group bluewifi
    ../USER/bluewifi/: bluewifi.c
  group mxml-3.0
    ../USER/mxml-3.0/: mxml-node.c mxml-search.c mxml-set.c mxml-string.c mxml-private.c mxml-attr.c mxml-entity.c mxml-file.c mxml-get.c mxml-index.c testmxml.c
  group FreeRTOS
    ../USER/FreeRTOS/: list.c queue.c tasks.c timers.c
    ../USER/FreeRTOS/portable/MemMang/: heap_2.c
    ../USER/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group STD_ODBII
    ../USER/STD_OBDII/: STD_OBD_CMD_PROCESS.c STD_OBD_SendRecv.c STD_TOYOTA_CMD_PROCESS.c STD_NISSAN_CMD_PROCESS.c STD_HONDA_CMD_PROCESS.c STD_FORD_CMD_PROCESS.c STD_VW_CMD_PROCESS.c STD_HYUNDAI_CMD_PROCESS.c STD_GMCN_CMD_PROCESS.c STD_GREATWALL_CMD_PROCESS.c
  group BootLoader
    ../USER/BootLoader/: App.c AppBinSave.c
  group 4G_DRV
    ../USER/4G_DRV/: 4G_Common_Api.c Fcar_Api.c 4G_FILE_Api.c
  group cJSON
    ../USER/cJSON/: cJSON.c my_queue.c udp_queue.c
  group Encryption Algorithm
    ../USER/Encryption_Algorithm/: md5.c sha1.c sha1test.c
  group CMD
    ../USER/CMD/: cmd.c cmdline.c
